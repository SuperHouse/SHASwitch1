# Repository SuperHouse/SHASwitch1

## EAGLE design SHASwitch1.brd

Parts:
ANT: M01PTH; 1X01
IC1: SPARKCORE
IC3: RXB1; RX-B1-SHORT-FLAT
JP1: M06SIP; 1X06
PIEZO1: BUZZERSMD12X12; BUZZER-12X12-SMT
PIEZO2: PIEZOPOLARISED; PIEZO12MMWIDEPOLARISED
R1: 2K2; 0603
R2: 1K; 0603
SW1: SWITCH-SPDT-ILLUMINATED

Connections:
5V: IC1.P$13 (VIN), JP1.1, SW1.1 (+)
A0_BUTTONS: IC1.P$24 (A0), R1.1, SW1.4 (NO)
D0_OUT1: IC1.P$1 (D0), JP1.2
D1_OUT2: IC1.P$2 (D1), JP1.3
D3_OUT3: IC1.P$4 (D3), JP1.4
D4_OUT4: IC1.P$5 (D4), JP1.5
D5: IC1.P$6 (D5)
D6: IC1.P$7 (D6)
D7_PIEZO: IC1.P$8 (D7), PIEZO1.1, PIEZO2.1 (+)
GND: IC1.P$9 (GND), IC1.P$14 (GND), IC3.1 (GND1), IC3.5 (GND2), JP1.6, PIEZO1.2, PIEZO2.2 (-), SW1.2 (-), SW1.5 (COM)
unnamed: ANT.1, IC3.6 (ANT)
unnamed: IC3.3 (DATA2), R2.2
RX433: IC1.P$3 (D2), R2.1
VCC: IC1.P$10 (3V3), IC1.P$12 (3V3), IC3.4 (VCC), R1.2

Notes on the sheet:
SKU: SWITCH1
SuperHouse Automation Switch 1
V1.0 (2015-07-14)
www.superhouse.tv/switch1

Board: 2 copper layers, 47.0 x 64.0 mm, 9 parts (2 on the bottom side), 12 nets.

## Commit log

2019-04-24 Initial project import

Notices in the files:
SHASwitch1.brd:
(C)2015 SuperHouse Automation P/L
parts and their libraries:
freetronics-original: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
